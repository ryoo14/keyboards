# Repository ryoo14/keyboards

File README.md:

# rhyn47

rhyn47 is a mechanical keyboard I designed.

It comes in three models: standard, low-profile and low-profile with trackball.

Please refer to the README file located in each keyboard's folder.

## Common Across All Models

- USB-C connectivity
- Direct-mounted RP2040 on the PCB
- 47-key ortholinear layout
- Hot-swapping switch support
- Screwless design
- Can be placed on top of a laptop (so-called “Sonshi style”)

## Standard

## Low-Profile

## Low-Profile with TrackBall

## KiCad design low-profile-with-trackball/pcb/low-profile-with-trackball/low-profile-with-trackball.kicad_pcb

File low-profile-with-trackball/README.md:

# rhyn47 low-profile with trackball

This is low-profile model of rhyn47 with trackball.

The case is the same as the [low-profile version](https://github.com/ryoo14/main/tree/rhyn47/low-profile).

It's a work in progress trackball case.

Parts:
C1, C2, C22, C23: 10uF; C_0402_1005Metric; JLCPCB Part # C15525
C3, C4: 2.2uF; C_0402_1005Metric; JLCPCB Part # C307418
C5, C6, C7, C8, C9, C10, C11, C12, C13: 100n; C_0402_1005Metric; JLCPCB Part # C1525
C14: 10uF; C_0805_2012Metric; JLCPCB Part # C15850
C15, C16: 10nF; C_0603_1608Metric; JLCPCB Part # C57112
C17: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C18, C19, C21: 100nF; C_0603_1608Metric; JLCPCB Part # C14663
C20: 3.3uF; C_0805_2012Metric; JLCPCB Part # C7393948
C24, C25: 20pF; C_0402_1005Metric; JLCPCB Part # C1554
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47: D; Diode_TH_SMD
F2: fuse; Fuse_1206_3216Metric; JLCPCB Part # C70076
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; JLCPCB Part # C165948
R1, R2: 27; R_0402_1005Metric; JLCPCB Part # C25100
R8: 1KΩ; R_0402_1005Metric; JLCPCB Part # C11702
R9, R10: 5.1k; R_0402_1005Metric; JLCPCB Part # C25905
R11: 10kΩ; R_0402_1005Metric; JLCPCB Part # C25744
R12: 10kΩ; R_0603_1608Metric; JLCPCB Part # C25804
R13: 1K; R_0402_1005Metric; JLCPCB Part # C11702
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47: SW_PUSH; Choc_v2_Hotswap_1u
SW48: boot; SW_Push_1P1T_XKB_TS-1187A; JLCPCB Part # C318884
U1: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; JLCPCB Part # C2040
U2: W25Q16JVUXIQ; W25Q16JVUXIQ_WIN; JLCPCB Part # C2843335
U3: PMW3610; PMW3610DM-SUDU 16Pin
U4: XC6206P332MR; SOT-23-3; JLCPCB Part # C5446
U5: SMF05CT1G; SOT-363-6_2P2X1P35_ONS; JLCPCB Rotation Offset 180
U6: MCP1700x-180xxTT; SOT-23; JLCPCB Part # C150796
Y1: X322512MSB4SI; Crystal_SMD_3225-4Pin_3.2x2.5mm; JLCPCB Part # C9002

Connections:
+1V1: C3.1, C5.1, C6.1, U1.23 (DVDD), U1.45 (VREG_VOUT), U1.50 (DVDD)
+1V8: C20.1, C21.1, C23.1, U3.14 (VDD), U6.2 (VO)
+3V3: C2.1, C4.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C17.1, C18.1, C22.1, R11.2, R12.2, U1.1 (IOVDD), U1.10 (IOVDD), U1.22 (IOVDD), U1.26 (RUN), U1.33 (IOVDD), U1.42 (IOVDD), U1.43 (ADC_AVDD), U1.44 (VREG_IN), U1.48 (USB_VDD), U1.49 (IOVDD), U2.8 (VCC), U3.6 (VDDIO), U4.2 (VO), U6.3 (VI)
+5V: C1.1, F2.2, U4.3 (VI), U5.4 (CATHODE)
Col0: SW1.1, SW13.1, SW25.1, SW37.1, U1.17 (GPIO14)
Col1: SW2.1, SW14.1, SW26.1, SW38.1, U1.16 (GPIO13)
Col2: SW3.1, SW15.1, SW27.1, SW39.1, U1.15 (GPIO12)
Col3: SW4.1, SW16.1, SW28.1, SW40.1, U1.3 (GPIO1)
Col4: SW5.1, SW17.1, SW29.1, SW41.1, U1.4 (GPIO2)
Col5: SW6.1, SW18.1, SW30.1, SW42.1, U1.5 (GPIO3)
Col6: SW7.1, SW19.1, SW31.1, U1.6 (GPIO4)
Col7: SW8.1, SW20.1, SW32.1, SW43.1, U1.7 (GPIO5)
Col8: SW9.1, SW21.1, SW33.1, SW44.1, U1.8 (GPIO6)
Col9: SW10.1, SW22.1, SW34.1, SW45.1, U1.12 (GPIO9)
Col10: SW11.1, SW23.1, SW35.1, SW46.1, U1.13 (GPIO10)
Col11: SW12.1, SW24.1, SW36.1, SW47.1, U1.14 (GPIO11)
D+: J2.A6 (D+), J2.B6 (D+), R1.1, U5.3 (CATHODE), U5.5 (CATHODE)
D-: J2.A7 (D-), J2.B7 (D-), R2.1, U5.1 (CATHODE), U5.6 (CATHODE)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R9.1, R10.1, SW48.2, U1.19 (TESTEN), U1.57 (GND), U2.4 (GND), U2.9 (EPAD), U3.11 (GND), U4.1 (GND), U5.2 (ANODE), U6.1 (GND), Y1.2, Y1.4
MOTION: U1.36 (GPIO24), U3.8 (MOTION)
unnamed: C25.2, R13.1, Y1.3
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: J2.A5 (CC1), R9.2
unnamed: J2.B5 (CC2), R10.2
unnamed: R2.2, U1.46 (USB_DM)
unnamed: R1.2, U1.47 (USB_DP)
unnamed: C16.1, U3.1 (+VCSEL), U3.10 (PASS_T)
unnamed: U3.15 (XYLASER), U3.16 (-VCSEL)
unnamed: C19.2, U3.13 (CN)
unnamed: C19.1, U3.12 (CP)
unnamed: R12.1, U3.7 (NRESET)
unnamed: C14.1, C15.1, U3.9 (VCP)
QSPI_SCLK: U1.52 (QSPI_SCLK), U2.6 (CLK)
QSPI_SD0: U1.53 (QSPI_SD0), U2.5 (DI(IO0))
QSPI_SD1: U1.55 (QSPI_SD1), U2.2 (DO(IO1))
QSPI_SD2: U1.54 (QSPI_SD2), U2.3 (/WP(IO2))
QSPI_SD3: U1.51 (QSPI_SD3), U2.7 (/HOLD_or_/RESET(IO3))
QSPI_SS: R8.1, R11.1, U1.56 (QSPI_SS), U2.1 (/CS)
Row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.32 (GPIO21)
Row1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.34 (GPIO22)
Row2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.31 (GPIO20)
Row3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), U1.30 (GPIO19)
SCLK: U1.38 (GPIO26_ADC0), U3.3 (SCLK)
SDIO: U1.39 (GPIO27_ADC1), U3.2 (SDIO)
USB_BOOT: R8.2, SW48.1
VBUS: F2.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
XIN: C24.2, U1.20 (XIN), Y1.1
XOUT: R13.2, U1.21 (XOUT)
nCS: U1.37 (GPIO25), U3.5 (NCS)

Notes on the sheet:
45PIN
※USBコネクタ近傍
※RP2040近傍
44PIN

Board: 2 copper layers, 228.8 x 76.2 mm, 137 parts (43 on the bottom side), 95 nets.

## KiCad design split-wireless/pcb/daughter/daughter.kicad_pcb

Parts:
C1, C4, C5: 10uF; C_0805_2012Metric; LCSC C15850
C2: 10nF; C_0805_2012Metric; LCSC C1710
C3: 20pF; C_0805_2012Metric; LCSC C1798
J1: Conn_01x20_Socket; FPC-SMD_20P-P0.50_0.5K-AS-20PWB; MPN 05B20U20P; LCSC Part C22435648
J2: Conn_01x02_Pin; BAT-TH_BH-AAA-A1AJ001; MPN BH-AAA-A1AJ001; LCSC Part C5290189
L1: 0.47uH; L_1008_2520Metric; LCSC C519277
Q1: Q_PMOS_GSD; SOT-23; LCSC C85097
Q2: Q_PMOS_GSD; SOT-23; LCSC C15127
R1, R6, R7: 150kΩ; R_0805_2012Metric; LCSC C17470
R2: 1MΩ; R_0805_2012Metric; LCSC C17514
R3, R4, R5: 470kΩ; R_0805_2012Metric; LCSC C17709
SW_BAT1: SW_SPDT; SW-SMD_SSSS811101; MPN SSSS811101; LCSC C109335
U1: XIAO-nRF52840-PLUS; XIAO-ESP32-S3-Plus-SMD
U2: TPS61021A; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm; LCSC C193037
U3: BU42; BU42XX; LCSC C2066584

Connections:
3.3V: J1.8, U1.12 (3V3)
5V: Q2.1 (G), R7.1, U1.14 (5V)
BAT: Q2.2 (S), U1.28 (BAT)
COL0: J1.14, U1.3 (P0.28_A2_D2)
COL1: J1.13, U1.2 (P0.03_A1_D1)
COL2: J1.12, U1.8 (P1.12_A7_D7_RX)
COL3: J1.11, U1.9 (P1.13_A8_D8_SCK)
COL4: J1.10, U1.10 (P1.14_A9_D9_MISO)
COL5: J1.9, U1.11 (P1.15_A10_D10_MOSI)
GND: C1.2, C2.1, C4.2, C5.2, J1.1, J1.5, J1.7, J1.15, J1.20, J1.21, J1.22, J2.1 (-), R1.1, R3.2, R6.2, R7.2, SW_BAT1.3, SW_BAT1.4, SW_BAT1.5, SW_BAT1.6, SW_BAT1.7, U1.13 (GND), U1.29 (GND2), U2.1 (AGND), U2.9 (GND), U3.3 (GND)
INPUT_VOLTAGE: C2.2, R2.2, R3.1, U1.1 (P0.02_A0_D0)
MOTION: J1.2, U1.15 (P0.15)
unnamed: J2.2 (+), Q1.3 (D)
unnamed: L1.2, U2.6 (SW), U2.7 (SW)
unnamed: Q1.1 (G), R1.2
unnamed: C1.1, L1.1, Q1.2 (S), R2.1, SW_BAT1.1, U2.8 (VIN), U3.2 (VDD)
unnamed: C3.1, C4.1, C5.1, Q2.3 (D), R5.1, U2.3 (VOUT), U2.4 (VOUT)
unnamed: R4.2, SW_BAT1.2
unnamed: R4.1, U2.5 (EN), U3.1 (Vout)
unnamed: C3.2, R5.2, R6.1, U2.2 (FB)
ROW0: J1.17, U1.7 (P1.11_A6_D6_TX)
ROW1: J1.18, U1.6 (P0.05_A5_D5_SCL)
ROW2: J1.19, U1.5 (P0.04_A4_D4_SDA)
ROW3: J1.16, U1.4 (P0.29_A3_D3)
SCIO: J1.4, U1.22 (P1.05)
SCLK: J1.6, U1.21 (P1.03)
nCS: J1.3, U1.23 (P1.07)

Notes on the sheet:
3.3V DC/DC Up Converter
Battery (Ni-Mh or 1.5V by default.)
Backflow prevention from USB power
Reverse connection protection
XIAO nRF52840 Plus
1.0V reset
Battery Voltage Monitor
FFC
Low VGS(th) required

Board: 2 copper layers, 101.0 x 26.0 mm, 21 parts (0 on the bottom side), 27 nets.

## Code that names these connections

File split-wireless/firmware/config/boards/shields/rhyn47/rhyn47.dtsi:

/*
 * rhyn47 (split-wireless) 共通定義
 *
 * 左右で同一のドーター基板（XIAO nRF52840 Plus + 電源）を使うため、
 * kscan・matrix-transform・電池監視はここに1回だけ書く。
 * 左右差（col-offset / トラックボール）は *_left.overlay / *_right.overlay で。
 *
 * 設計書: wireless-rhyn-design.md §4, §7 / 実装ノート: zmk-implementation-notes.md §3-§5, §8
 */

#include <dt-bindings/zmk/matrix_transform.h>
#include <zephyr/dt-bindings/gpio/gpio.h>
#include <zephyr/dt-bindings/adc/adc.h>
#include <zephyr/dt-bindings/adc/nrf-adc.h>

/ {
    chosen {
        zmk,kscan = &kscan0;
        zmk,matrix-transform = &default_transform;
        zmk,battery = &vbatt_ext;
    };

    /*
     * マトリクス 4行 × 6列（片側24キー）
     * ダイオードは全キー同じ向き = col2row。外部プルアップ抵抗なし（内蔵プル使用）。
     *
     * ⚠ col2row では ROW=入力かつ内蔵プル"ダウン" / COL=出力 ACTIVE_HIGH になる
     *   （設計書 §12.7 の「内蔵プルアップ」は「外部抵抗なし」の意で読むこと）。
     *   実基板のダイオード向きが逆だったら row2col + PULL_UP / ACTIVE_LOW に変更。
     */
    kscan0: kscan {
        compatible = "zmk,kscan-gpio-matrix";
        diode-direction = "col2row";
        wakeup-source;

        row-gpios
            = <&gpio0  3 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>   // ROW0 = D1 / P0.03
            , <&gpio0 28 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>   // ROW1 = D2 / P0.28
            , <&gpio0 29 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>   // ROW2 = D3 / P0.29
            , <&gpio0  4 (GPIO_ACTIVE_HIGH | GPIO_PULL_DOWN)>   // ROW3 = D4 / P0.04
            ;

        col-gpios
            = <&gpio0  5 GPIO_ACTIVE_HIGH>   // COL0 = D5  / P0.05
            , <&gpio1 11 GPIO_ACTIVE_HIGH>   // COL1 = D6  / P1.11
            , <&gpio1 12 GPIO_ACTIVE_HIGH>   // COL2 = D7  / P1.12
            , <&gpio1 13 GPIO_ACTIVE_HIGH>   // COL3 = D8  / P1.13
            , <&gpio1 14 GPIO_ACTIVE_HIGH>   // COL4 = D9  / P1.14
            , <&gpio1 15 GPIO_ACTIVE_HIGH>   // COL5 = D10 / P1.15
            ;
    };

    /*
     * 論理グリッド 4行 × 12列。左=列0-5 / 右=列6-11（右 overlay で col-offset=6）。
     * 右手の最下段・最内側 RC(3,6) がトラックボール位置なので map から省く。
     *   → 総キー数 47（左24 + 右23）。QMK 版 keymap.c の row3 index6 = KC_NO と一致。
     *
     * バインド順は下の map の並び順そのまま。row0=12 / row1=12 / row2=12 / row3=11。
     */
    default_transform: keymap_transform_0 {
        compatible = "zmk,matrix-transform";
        columns = <12>;
        rows = <4>;
        //          左手 (col 0-5)                            右手 (col 6-11)
        map = <
RC(0,0) RC(0,1) RC(0,2) RC(0,3) RC(0,4) RC(0,5)   RC(0,6) RC(0,7) RC(0,8) RC(0,9) RC(0,10) RC(0,11)
RC(1,0) RC(1,1) RC(1,2) RC(1,3) RC(1,4) RC(1,5)   RC(1,6) RC(1,7) RC(1,8) RC(1,9) RC(1,10) RC(1,11)
RC(2,0) RC(2,1) RC(2,2) RC(2,3) RC(2,4) RC(2,5)   RC(2,6) RC(2,7) RC(2,8) RC(2,9) RC(2,10) RC(2,11)
RC(3,0) RC(3,1) RC(3,2) RC(3,3) RC(3,4) RC(3,5)           RC(3,7) RC(3,8) RC(3,9) RC(3,10) RC(3,11)
        >;                                     /* ↑ RC(3,6) = トラックボール */
    };

    /*
     * 電池電圧監視（設計書 §4, §7 / 実装ノート §8）
     * 単4×1 の生電圧を外部分圧 1MΩ / 470kΩ で A0 (P0.02 = AIN0) に入れる。
     * power-gpios なし（常時ONの分圧、約1µA）。
     */
    vbatt_ext: vbatt_ext {
        compatible = "zmk,battery-voltage-divider";
        io-channels = <&adc 0>;
        output-ohms = <470000>;
        full-ohms = <(1000000 + 470000)>;
    };
};

/* ボード標準のオンボード分圧（P0.31 / P0.14 制御）は使わないので止める */
&vbatt {
    status = "disabled";
};

&adc {
    status = "okay";
    #address-cells = <1>;
    #size-cells = <0>;

    /* AIN0 = P0.02 = D0。ビルドが通らなければこの channel@0 ごと削って
       ボード標準 vbatt と同じ「io-channels だけ」の書式に戻す（実装ノート §8）。 */
    channel@0 {
        reg = <0>;
        zephyr,gain = "ADC_GAIN_1_6";              /* フルスケール 0.6V × 6 = 3.6V */
        zephyr,reference = "ADC_REF_INTERNAL";     /* 0.6V */
        zephyr,acquisition-time = <ADC_ACQ_TIME(ADC_ACQ_TIME_MICROSECONDS, 10)>;
        zephyr,input-positive = <NRF_SAADC_AIN0>;
        zephyr,resolution = <12>;
    };
};

## Commit log (part)

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2025-05-05 chore: ignore lck file
2025-05-05 fix: adjust to prevent the screws at the four corners from interfering with the PCB
2025-05-05 fix: fix the typo and adjust the size of the silkscreen in the bottom right corner
2025-05-06 chore: clean up routing and add edge vias
2025-05-06 fix: avoid orthogonal traces through vias
2025-05-09 chore: change the surface pattern to a more detailed one
2025-05-09 feat: rewire myself
2025-05-09 chore: gnd beta
2025-05-09 chore: for jlcpcb
2025-05-09 chore: add big icon
2025-05-10 chore: change icons
2025-05-10 chore: etc
2025-05-10 feat: switch plate for 3d print case
2025-05-25 chore: step files for 3dcase
2025-06-03 chore: lower case
2025-06-03 direct mcu
2025-06-04 chore refactor folder structure
2025-06-09 feat: add firmware files
2025-06-09 chore: rename keyboard name
2025-06-12 feat: vial firmware
2025-06-14 chore: add parts number for jlcpcb
2025-06-14 feat: add case's step files
2025-06-14 chore: move vial firmware to qmk directory
2025-06-14 doc: write readme
2025-06-14 doc: fix make command
2025-06-14 docs: add filename for cases
2025-06-15 chore: fix readme
2025-06-17 chore: rename keyboard
2025-06-23 chore: add jlcparts number
2025-06-23 chore: remove the leading slash
2025-06-23 docs: simplify the readme
2025-10-01 add rhyl47
2025-10-01 add readme
2025-10-01 fix profile
2025-10-18 generate vial id and change diode direction
2025-11-08 ignore *.FCBak file
2025-11-08 export pdf
2025-11-08 update case design for aluminum cnc!
2025-11-22 add photos
2025-12-30 chore: add photos
2025-12-30 chore: fix keyboard name
2026-04-27 new keyboard based on rhyl47 with track ball
2026-04-27 modify license
2026-04-28 remove title
2026-04-28 rename keyboards
2026-04-28 fix typo etc
2026-04-28 add keycode to scroll layer
2026-05-01 add trackball case data
2026-05-02 chagne dionde_detection
2026-05-02 only save
2026-05-02 reverse scroll
2026-05-02 remove mask
2026-05-04 add keycode for trackball
2026-05-04 remove unneed mod
2026-05-09 update readme.
2026-05-09 update non-conductive zone pattern
2026-05-09 remove production files
2026-06-13 make the hole for the magnet 1mm shallower
2026-06-13 add [3, 6] to keymap
