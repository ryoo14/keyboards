/*
 * rhyn47 左手（ペリフェラル・トラックボールなし）
 *
 * col-offset は既定の 0 のままなので、物理列0-5 = 論理列0-5。
 * 左メイン基板にはセンサーが無いので SPI/PMW3610 は一切書かない
 *   → クロックも通信も出ず、無駄な電力を食わない（設計書 §12.7）。
 */

#include "rhyn47.dtsi"
